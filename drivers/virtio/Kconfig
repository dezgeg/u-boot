## drivers/virtio/Kconfig
```kconfig
menu "Virtio Support"

config VIRTIO
	bool "Enable Virtio"
	help
	  Enable Virtio.

endmenu # menu "Virtio Support"
```
